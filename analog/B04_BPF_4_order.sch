v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -220 -540 -220 -520 {lab=#net1}
N -220 -520 60 -520 {lab=#net1}
N 60 -570 60 -520 {lab=#net1}
N 160 -960 160 -570 {lab=#net1}
N 60 -570 160 -570 {lab=#net1}
N 720 -1030 720 -570 {lab=#net1}
N 160 -570 720 -570 {lab=#net1}
N 720 -570 1290 -570 {lab=#net1}
N 1290 -960 1290 -570 {lab=#net1}
N 1790 -1030 1790 -570 {lab=#net1}
N 1290 -570 1790 -570 {lab=#net1}
N 240 -1210 240 -1090 {lab=VDD}
N 1880 -1210 1880 -1090 {lab=VDD}
N 240 -1210 1880 -1210 {lab=VDD}
N 810 -1210 810 -1090 {lab=VDD}
N 1380 -1210 1380 -1090 {lab=VDD}
N -180 -1210 -180 -670 {lab=VDD}
N -180 -1210 240 -1210 {lab=VDD}
N -170 -450 -170 -0 {lab=#net2}
N -130 -450 -130 -0 {lab=#net3}
N -110 -450 -110 -0 {lab=#net4}
N 250 -870 250 0 {lab=#net5}
N 270 -870 270 0 {lab=#net6}
N 290 -870 290 -0 {lab=#net7}
N 310 -870 310 -0 {lab=#net8}
N 820 -870 820 0 {lab=#net9}
N 840 -870 840 0 {lab=#net10}
N 860 -870 860 0 {lab=#net11}
N 880 -870 880 0 {lab=#net12}
N 1390 -870 1390 0 {lab=#net13}
N 1410 -870 1410 0 {lab=#net14}
N 1430 -870 1430 0 {lab=#net15}
N 1450 -870 1450 0 {lab=#net16}
N 1890 -870 1890 0 {lab=#net17}
N 1910 -870 1910 0 {lab=#net18}
N 1930 -870 1930 0 {lab=#net19}
N 1950 -870 1950 0 {lab=#net20}
N 1190 70 1690 70 {lab=#net21}
N 1190 90 1690 90 {lab=#net22}
N 620 70 1190 70 {lab=#net21}
N 620 90 1190 90 {lab=#net22}
N 50 70 620 70 {lab=#net21}
N 50 90 620 90 {lab=#net22}
N -370 70 50 70 {lab=#net21}
N -370 90 50 90 {lab=#net22}
N -480 70 -370 70 {lab=#net21}
N -480 60 -480 70 {lab=#net21}
N -480 90 -370 90 {lab=#net22}
N -480 90 -480 100 {lab=#net22}
N 1730 -110 1730 -0 {lab=VDD}
N -90 -110 1730 -110 {lab=VDD}
N 1750 -90 1750 -0 {lab=GND}
N -80 -90 1750 -90 {lab=GND}
N 1230 -110 1230 -0 {lab=VDD}
N 1250 -90 1250 0 {lab=GND}
N 680 -90 680 -0 {lab=GND}
N 660 -110 660 -0 {lab=VDD}
N 110 -90 110 -0 {lab=GND}
N 90 -110 90 -0 {lab=VDD}
N -630 -110 -90 -110 {lab=VDD}
N -630 -110 -630 20 {lab=VDD}
N -630 140 -600 140 {lab=GND}
N -600 -90 -600 140 {lab=GND}
N -600 -90 -80 -90 {lab=GND}
N -330 -110 -330 -0 {lab=VDD}
N -310 -90 -310 -0 {lab=GND}
N -630 -1210 -630 -110 {lab=VDD}
N -630 -1210 -180 -1210 {lab=VDD}
N 1750 -90 1870 -90 {lab=GND}
N -630 -840 -420 -840 {lab=VDD}
N -420 -840 -420 -770 {lab=VDD}
N -420 -710 -420 -520 {lab=#net23}
N -420 -460 -420 -90 {lab=GND}
N -190 -460 -190 -90 {lab=GND}
N -420 -610 -220 -610 {lab=#net23}
N 1870 -820 2400 -820 {lab=GND}
N 1880 -1210 4050 -1210 {lab=VDD}
N -150 -450 -150 -0 {lab=#net24}
N 2340 -960 2340 -570 {lab=#net1}
N 2400 -880 2400 -820 {lab=GND}
N 2400 -820 2970 -820 {lab=GND}
N 2970 -880 2970 -820 {lab=GND}
N 2970 -820 3540 -820 {lab=GND}
N 3540 -880 3540 -820 {lab=GND}
N 3540 -820 4040 -820 {lab=GND}
N 4040 -880 4040 -820 {lab=GND}
N 4050 -1210 4050 -1090 {lab=VDD}
N 3550 -1210 3550 -1090 {lab=VDD}
N 2980 -1210 2980 -1090 {lab=VDD}
N 2410 -1210 2410 -1090 {lab=VDD}
N 2650 -990 2940 -990 {lab=#net25}
N 2940 -990 2940 -960 {lab=#net25}
N 3220 -990 3510 -990 {lab=#net25}
N 3790 -990 4010 -990 {lab=#net26}
N 4010 -990 4010 -960 {lab=#net26}
N 2340 -570 2900 -570 {lab=#net1}
N 2900 -1030 2900 -570 {lab=#net1}
N 2900 -1030 2940 -1030 {lab=#net1}
N 2900 -570 3450 -570 {lab=#net1}
N 3450 -960 3450 -570 {lab=#net1}
N 3450 -570 3950 -570 {lab=#net1}
N 3950 -1030 3950 -570 {lab=#net1}
N 3950 -1030 4010 -1030 {lab=#net1}
N 3260 -990 3260 -960 {lab=#net25}
N 3260 -900 3260 -820 {lab=GND}
N 3830 -990 3830 -960 {lab=#net26}
N 3830 -900 3830 -820 {lab=GND}
N 4290 -1130 4290 -990 {lab=#net25}
N 3510 -1130 4290 -1130 {lab=#net25}
N 2340 -960 2370 -960 {lab=#net1}
N 2370 -1030 2370 -990 {lab=#net27}
N 2340 -960 2370 -960 {lab=#net1}
N 2220 -990 2370 -990 {lab=#net27}
N 230 -880 230 -820 {lab=GND}
N 230 -820 800 -820 {lab=GND}
N 800 -880 800 -820 {lab=GND}
N 800 -820 1370 -820 {lab=GND}
N 1370 -880 1370 -820 {lab=GND}
N 1370 -820 1870 -820 {lab=GND}
N 1870 -880 1870 -820 {lab=GND}
N 1120 -930 1120 -820 {lab=GND}
N 1680 -930 1680 -820 {lab=GND}
N 2120 -1130 2120 -990 {lab=#net27}
N 1330 -1130 2120 -1130 {lab=#net27}
N 1330 -1130 1330 -1030 {lab=#net27}
N -30 -1030 200 -1030 {lab=Vin}
N 480 -990 770 -990 {lab=#net27}
N 770 -990 770 -960 {lab=#net27}
N 1620 -990 1840 -990 {lab=#net28}
N 1840 -990 1840 -960 {lab=#net28}
N 1050 -990 1340 -990 {lab=#net27}
N 1340 -1030 1340 -990 {lab=#net27}
N 160 -960 200 -960 {lab=#net1}
N 720 -1030 770 -1030 {lab=#net1}
N 1290 -960 1340 -960 {lab=#net1}
N 1790 -1030 1840 -1030 {lab=#net1}
N 1330 -1030 1340 -1030 {lab=#net27}
N 2120 -990 2160 -990 {lab=#net27}
N 2160 -990 2220 -990 {lab=#net27}
N 3450 -960 3510 -960 {lab=#net1}
N 3510 -1030 3510 -990 {lab=#net25}
N 3510 -1130 3510 -1030 {lab=#net25}
N 690 -1120 690 -990 {lab=#net27}
N 690 -1120 1090 -1120 {lab=#net27}
N 1090 -1120 1090 -990 {lab=#net27}
N 2830 -1150 2830 -990 {lab=#net25}
N 2830 -1150 3210 -1150 {lab=#net25}
N 3210 -1150 3260 -1150 {lab=#net25}
N 3260 -1150 3260 -990 {lab=#net25}
N 1790 -570 2340 -570 {lab=#net1}
N 3360 70 3860 70 {lab=#net21}
N 3360 90 3860 90 {lab=#net22}
N 2790 70 3360 70 {lab=#net21}
N 2790 90 3360 90 {lab=#net22}
N 2220 70 2790 70 {lab=#net21}
N 2220 90 2790 90 {lab=#net22}
N 1800 70 2220 70 {lab=#net21}
N 1800 90 2220 90 {lab=#net22}
N 2080 -110 3900 -110 {lab=VDD}
N 2090 -90 3920 -90 {lab=GND}
N 4040 -820 4040 -90 {lab=GND}
N 3920 -90 4040 -90 {lab=GND}
N 1690 70 1800 70 {lab=#net21}
N 1690 90 1800 90 {lab=#net22}
N 1870 -90 2090 -90 {lab=GND}
N 1730 -110 2080 -110 {lab=VDD}
N -440 -740 -440 -490 {lab=GND}
N -440 -490 -440 -90 {lab=GND}
N 4050 -1210 4470 -1210 {lab=VDD}
N 4470 -1210 4470 -1080 {lab=VDD}
N 4040 -90 4340 -90 {lab=GND}
N 4340 -90 4340 10 {lab=GND}
N 3900 -110 4320 -110 {lab=VDD}
N 4320 -110 4320 10 {lab=VDD}
N 3860 70 4280 80 {lab=#net21}
N 3860 90 4280 100 {lab=#net22}
N 3950 -570 4300 -570 {lab=#net1}
N 4290 -990 4430 -990 {lab=#net25}
N 4040 -820 4460 -820 {lab=GND}
N 4460 -870 4460 -820 {lab=GND}
N 4480 -860 4480 10 {lab=#net29}
N 4500 -860 4500 10 {lab=#net30}
N 4520 -860 4520 10 {lab=#net31}
N 4540 -860 4540 10 {lab=#net32}
N 4710 -980 4710 -950 {lab=Vout}
N 4710 -950 4710 -930 {lab=Vout}
N 4670 -930 4710 -930 {lab=Vout}
N 4420 -950 4420 -930 {lab=#net33}
N 4420 -950 4430 -950 {lab=#net33}
N 4430 -1020 4430 -990 {lab=#net25}
N 4710 -1030 4880 -1030 {lab=Vout}
N 4710 -1030 4710 -980 {lab=Vout}
N 4420 -930 4610 -930 {lab=#net33}
N 4670 -930 4670 -880 {lab=Vout}
N 4610 -930 4610 -880 {lab=#net33}
N 4360 -950 4360 -570 {lab=#net1}
N 4300 -570 4360 -570 {lab=#net1}
N 4120 -870 4120 -200 {lab=#net20}
N 4100 -870 4100 -220 {lab=#net19}
N 4080 -870 4080 -240 {lab=#net18}
N 4060 -870 4060 -270 {lab=#net17}
N 4060 -270 4060 -260 {lab=#net17}
N 3620 -870 3620 -320 {lab=#net16}
N 3600 -870 3600 -330 {lab=#net15}
N 3580 -870 3580 -340 {lab=#net14}
N 3560 -870 3560 -350 {lab=#net13}
N 3050 -870 3050 -420 {lab=#net12}
N 3030 -870 3030 -430 {lab=#net11}
N 3010 -870 3010 -440 {lab=#net10}
N 2990 -870 2990 -450 {lab=#net9}
N 2480 -870 2480 -520 {lab=#net8}
N 2460 -870 2460 -530 {lab=#net7}
N 2440 -870 2440 -540 {lab=#net6}
N 2420 -870 2420 -550 {lab=#net5}
N 1890 -260 4060 -260 {lab=#net17}
N 1910 -240 4080 -240 {lab=#net18}
N 1930 -220 4100 -220 {lab=#net19}
N 1950 -200 4120 -200 {lab=#net20}
N 1390 -350 3560 -350 {lab=#net13}
N 1410 -340 3580 -340 {lab=#net14}
N 1430 -330 3600 -330 {lab=#net15}
N 1450 -320 3620 -320 {lab=#net16}
N 820 -450 2990 -450 {lab=#net9}
N 840 -440 3010 -440 {lab=#net10}
N 860 -430 3030 -430 {lab=#net11}
N 880 -420 3050 -420 {lab=#net12}
N 250 -550 2420 -550 {lab=#net5}
N 270 -540 2440 -540 {lab=#net6}
N 290 -530 2460 -530 {lab=#net7}
N 310 -520 2480 -520 {lab=#net8}
C {iopin.sym} 890 -1210 3 0 {name=p1 lab=VDD}
C {iopin.sym} -600 140 1 0 {name=p2 lab=GND}
C {ipin.sym} -20 -1030 0 0 {name=p3 lab=Vin}
C {opin.sym} 4710 -1010 0 0 {name=p5 lab=Vout}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_beta_multiplier_reference.sym} -630 80 0 0 {name=x1 length=410u}
C {symbols/cap_mim_2f0fF.sym} 1120 -960 0 0 {name=C5
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=\{m_cap\}}
C {code_shown.sym} 1150 -1050 0 0 {name=s1 only_toplevel=false value=".param m_cap=48"}
C {symbols/cap_mim_2f0fF.sym} 1680 -960 0 0 {name=C1
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=\{m_cap\}}
C {symbols/cap_mim_2f0fF.sym} 3260 -930 0 0 {name=C2
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=\{m_cap\}}
C {symbols/cap_mim_2f0fF.sym} 3830 -930 0 0 {name=C3
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=\{m_cap\}}
C {symbols/ppolyf_u_2k.sym} -420 -490 0 0 {name=R2
W=2u
L=300u
model=ppolyf_u_2k
spiceprefix=X
m=1}
C {symbols/ppolyf_u_2k.sym} -420 -740 0 0 {name=R1
W=2u
L=300u
model=ppolyf_u_2k
spiceprefix=X
m=1}
C {code_shown.sym} 3310 -1120 0 0 {name=s2 only_toplevel=false value=".param m_cap_1=30"}
C {res.sym} 4640 -880 1 0 {name=R3
value=9G
footprint=1206
device=resistor
m=1}
C {capa.sym} 4390 -950 1 0 {name=C4
m=1
value=9p
footprint=1206
device="ceramic capacitor"}
C {capa.sym} 4640 -930 1 0 {name=C6
m=1
value=1p
footprint=1206
device="ceramic capacitor"}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_core.sym} -230 90 0 0 {name=x16 ratio=5}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_core.sym} 190 90 0 0 {name=x2 ratio=0.15}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_core.sym} 760 90 0 0 {name=x8 ratio=0.15}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_core.sym} 1330 90 0 0 {name=x9 ratio=0.29}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_core.sym} 1830 90 0 0 {name=x10 ratio=0.3}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_core.sym} 4420 100 0 0 {name=x11 ratio=5}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} -100 -560 0 0 {name=x7}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 320 -980 0 0 {name=x3}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 890 -980 0 0 {name=x4}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 1460 -980 0 0 {name=x5}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 1960 -980 0 0 {name=x6}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 2490 -980 0 0 {name=x12}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 3060 -980 0 0 {name=x13}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 3630 -980 0 0 {name=x14}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 4130 -980 0 0 {name=x15}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_folded_cascode_OTA.sym} 4550 -970 0 0 {name=x17}
