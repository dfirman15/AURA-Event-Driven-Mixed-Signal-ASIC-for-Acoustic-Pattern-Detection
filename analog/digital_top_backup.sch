v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {ipin.sym} 660 -840 0 0 {name=p1 lab=sda}
C {ipin.sym} 660 -820 0 0 {name=p2 lab=scl}
C {ipin.sym} 660 -790 0 0 {name=p3 lab=en}
C {ipin.sym} 660 -760 0 0 {name=p4 lab=comp_out}
C {ipin.sym} 660 -730 0 0 {name=p5 lab=clk}
C {iopin.sym} 780 -880 0 0 {name=p6 lab=VDD}
C {iopin.sym} 780 -830 0 0 {name=p7 lab=VSS}
C {opin.sym} 970 -880 0 0 {name=p8 lab=cap_ctrl[0]}
C {opin.sym} 970 -850 0 0 {name=p9 lab=cap_ctrl[1]}
C {opin.sym} 970 -820 0 0 {name=p10 lab=cap_ctrl[2]}
C {opin.sym} 970 -770 0 0 {name=p11 lab=trigger_out}
