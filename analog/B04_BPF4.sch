v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 160 -960 160 -570 {lab=VDD05}
N 60 -570 160 -570 {lab=VDD05}
N 720 -1030 720 -570 {lab=VDD05}
N 160 -570 720 -570 {lab=VDD05}
N 720 -570 1290 -570 {lab=VDD05}
N 1290 -960 1290 -570 {lab=VDD05}
N 1790 -1030 1790 -570 {lab=VDD05}
N 1290 -570 1790 -570 {lab=VDD05}
N 240 -1210 240 -1090 {lab=VDD}
N 1880 -1210 1880 -1090 {lab=VDD}
N 240 -1210 1880 -1210 {lab=VDD}
N 810 -1210 810 -1090 {lab=VDD}
N 1380 -1210 1380 -1090 {lab=VDD}
N -180 -1210 240 -1210 {lab=VDD}
N 250 -870 250 0 {lab=#net1}
N 270 -870 270 0 {lab=#net2}
N 290 -870 290 -0 {lab=#net3}
N 310 -870 310 -0 {lab=#net4}
N 820 -870 820 0 {lab=#net5}
N 840 -870 840 0 {lab=#net6}
N 860 -870 860 0 {lab=#net7}
N 880 -870 880 0 {lab=#net8}
N 1390 -870 1390 0 {lab=#net9}
N 1410 -870 1410 0 {lab=#net10}
N 1430 -870 1430 0 {lab=#net11}
N 1450 -870 1450 0 {lab=#net12}
N 1890 -870 1890 0 {lab=#net13}
N 1910 -870 1910 0 {lab=#net14}
N 1930 -870 1930 0 {lab=#net15}
N 1950 -870 1950 0 {lab=#net16}
N 1190 70 1690 70 {lab=VbiasP}
N 1190 90 1690 90 {lab=VbiasN}
N 620 70 1190 70 {lab=VbiasP}
N 620 90 1190 90 {lab=VbiasN}
N 50 70 620 70 {lab=VbiasP}
N 50 90 620 90 {lab=VbiasN}
N 1730 -110 1730 -0 {lab=VDD}
N -90 -110 1730 -110 {lab=VDD}
N 1750 -90 1750 -0 {lab=GND}
N -80 -90 1750 -90 {lab=GND}
N 1230 -110 1230 -0 {lab=VDD}
N 1250 -90 1250 0 {lab=GND}
N 680 -90 680 -0 {lab=GND}
N 660 -110 660 -0 {lab=VDD}
N 110 -90 110 -0 {lab=GND}
N 90 -110 90 -0 {lab=VDD}
N -630 -110 -90 -110 {lab=VDD}
N -600 -90 -600 140 {lab=GND}
N -600 -90 -80 -90 {lab=GND}
N -630 -1210 -630 -110 {lab=VDD}
N -630 -1210 -180 -1210 {lab=VDD}
N 1750 -90 1870 -90 {lab=GND}
N 1870 -820 2400 -820 {lab=GND}
N 1880 -1210 4050 -1210 {lab=VDD}
N 2340 -960 2340 -570 {lab=VDD05}
N 2400 -880 2400 -820 {lab=GND}
N 2400 -820 2970 -820 {lab=GND}
N 2970 -880 2970 -820 {lab=GND}
N 2970 -820 3540 -820 {lab=GND}
N 3540 -880 3540 -820 {lab=GND}
N 3540 -820 4040 -820 {lab=GND}
N 4040 -880 4040 -820 {lab=GND}
N 4050 -1210 4050 -1090 {lab=VDD}
N 3550 -1210 3550 -1090 {lab=VDD}
N 2980 -1210 2980 -1090 {lab=VDD}
N 2410 -1210 2410 -1090 {lab=VDD}
N 2650 -990 2940 -990 {lab=#net17}
N 2940 -990 2940 -960 {lab=#net17}
N 3220 -990 3510 -990 {lab=#net17}
N 3790 -990 4010 -990 {lab=#net18}
N 4010 -990 4010 -960 {lab=#net18}
N 2340 -570 2900 -570 {lab=VDD05}
N 2900 -1030 2900 -570 {lab=VDD05}
N 2900 -1030 2940 -1030 {lab=VDD05}
N 2900 -570 3450 -570 {lab=VDD05}
N 3450 -960 3450 -570 {lab=VDD05}
N 3450 -570 3950 -570 {lab=VDD05}
N 3950 -1030 3950 -570 {lab=VDD05}
N 3950 -1030 4010 -1030 {lab=VDD05}
N 3260 -990 3260 -960 {lab=#net17}
N 3260 -900 3260 -820 {lab=GND}
N 3830 -990 3830 -960 {lab=#net18}
N 3830 -900 3830 -820 {lab=GND}
N 4290 -1130 4290 -990 {lab=#net17}
N 3510 -1130 4290 -1130 {lab=#net17}
N 2340 -960 2370 -960 {lab=VDD05}
N 2370 -1030 2370 -990 {lab=#net19}
N 2340 -960 2370 -960 {lab=VDD05}
N 2220 -990 2370 -990 {lab=#net19}
N 230 -880 230 -820 {lab=GND}
N 230 -820 800 -820 {lab=GND}
N 800 -880 800 -820 {lab=GND}
N 800 -820 1370 -820 {lab=GND}
N 1370 -880 1370 -820 {lab=GND}
N 1370 -820 1870 -820 {lab=GND}
N 1870 -880 1870 -820 {lab=GND}
N 960 -1460 960 -1350 {lab=GND}
N 2120 -1130 2120 -990 {lab=#net19}
N 1330 -1130 2120 -1130 {lab=#net19}
N 1330 -1130 1330 -1030 {lab=#net19}
N -30 -1030 200 -1030 {lab=Vin}
N 480 -990 770 -990 {lab=#net19}
N 770 -990 770 -960 {lab=#net19}
N 1620 -990 1840 -990 {lab=#net20}
N 1840 -990 1840 -960 {lab=#net20}
N 1050 -990 1340 -990 {lab=#net19}
N 1340 -1030 1340 -990 {lab=#net19}
N 160 -960 200 -960 {lab=VDD05}
N 720 -1030 770 -1030 {lab=VDD05}
N 1290 -960 1340 -960 {lab=VDD05}
N 1790 -1030 1840 -1030 {lab=VDD05}
N 1330 -1030 1340 -1030 {lab=#net19}
N 2120 -990 2160 -990 {lab=#net19}
N 2160 -990 2220 -990 {lab=#net19}
N 3450 -960 3510 -960 {lab=VDD05}
N 3510 -1030 3510 -990 {lab=#net17}
N 3510 -1130 3510 -1030 {lab=#net17}
N 690 -1120 690 -990 {lab=#net19}
N 690 -1120 1090 -1120 {lab=#net19}
N 1090 -1120 1090 -990 {lab=#net19}
N 2830 -1150 2830 -990 {lab=#net17}
N 2830 -1150 3210 -1150 {lab=#net17}
N 3210 -1150 3260 -1150 {lab=#net17}
N 3260 -1150 3260 -990 {lab=#net17}
N 1790 -570 2340 -570 {lab=VDD05}
N 3360 70 3860 70 {lab=VbiasP}
N 3360 90 3860 90 {lab=VbiasN}
N 2790 70 3360 70 {lab=VbiasP}
N 2790 90 3360 90 {lab=VbiasN}
N 2220 70 2790 70 {lab=VbiasP}
N 2220 90 2790 90 {lab=VbiasN}
N 1800 70 2220 70 {lab=VbiasP}
N 1800 90 2220 90 {lab=VbiasN}
N 2080 -110 3900 -110 {lab=VDD}
N 2090 -90 3920 -90 {lab=GND}
N 4040 -820 4040 -90 {lab=GND}
N 3920 -90 4040 -90 {lab=GND}
N 1690 70 1800 70 {lab=VbiasP}
N 1690 90 1800 90 {lab=VbiasN}
N 1870 -90 2090 -90 {lab=GND}
N 1730 -110 2080 -110 {lab=VDD}
N 4050 -1210 4470 -1210 {lab=VDD}
N 4040 -90 4340 -90 {lab=GND}
N 3900 -110 4320 -110 {lab=VDD}
N 3860 70 4280 80 {lab=VbiasP}
N 3860 90 4280 100 {lab=VbiasN}
N 3950 -570 4300 -570 {lab=VDD05}
N 4040 -820 4460 -820 {lab=GND}
N 4300 -570 4360 -570 {lab=VDD05}
N 4120 -870 4120 -200 {lab=#net16}
N 4100 -870 4100 -220 {lab=#net15}
N 4080 -870 4080 -240 {lab=#net14}
N 4060 -870 4060 -270 {lab=#net13}
N 4060 -270 4060 -260 {lab=#net13}
N 3620 -870 3620 -320 {lab=#net12}
N 3600 -870 3600 -330 {lab=#net11}
N 3580 -870 3580 -340 {lab=#net10}
N 3560 -870 3560 -350 {lab=#net9}
N 3050 -870 3050 -420 {lab=#net8}
N 3030 -870 3030 -430 {lab=#net7}
N 3010 -870 3010 -440 {lab=#net6}
N 2990 -870 2990 -450 {lab=#net5}
N 2480 -870 2480 -520 {lab=#net4}
N 2460 -870 2460 -530 {lab=#net3}
N 2440 -870 2440 -540 {lab=#net2}
N 2420 -870 2420 -550 {lab=#net1}
N 1890 -260 4060 -260 {lab=#net13}
N 1910 -240 4080 -240 {lab=#net14}
N 1930 -220 4100 -220 {lab=#net15}
N 1950 -200 4120 -200 {lab=#net16}
N 1390 -350 3560 -350 {lab=#net9}
N 1410 -340 3580 -340 {lab=#net10}
N 1430 -330 3600 -330 {lab=#net11}
N 1450 -320 3620 -320 {lab=#net12}
N 820 -450 2990 -450 {lab=#net5}
N 840 -440 3010 -440 {lab=#net6}
N 860 -430 3030 -430 {lab=#net7}
N 880 -420 3050 -420 {lab=#net8}
N 250 -550 2420 -550 {lab=#net1}
N 270 -540 2440 -540 {lab=#net2}
N 290 -530 2460 -530 {lab=#net3}
N 310 -520 2480 -520 {lab=#net4}
N 1020 -760 1060 -760 {lab=GND}
N 1020 -820 1020 -760 {lab=GND}
N 1640 -760 1680 -760 {lab=GND}
N 1640 -820 1640 -760 {lab=GND}
N 3220 -760 3260 -760 {lab=GND}
N 3220 -820 3220 -760 {lab=GND}
N 3790 -760 3830 -760 {lab=GND}
N 3790 -820 3790 -760 {lab=GND}
N 4320 -110 4320 10 {lab=VDD}
N 4340 -90 4340 10 {lab=GND}
N 4510 -840 4510 -820 {lab=GND}
N 4460 -820 4510 -820 {lab=GND}
N 4470 -1210 4510 -1210 {lab=VDD}
N 4510 -1210 4520 -1050 {lab=VDD}
N 4480 10 4530 -830 {lab=#net21}
N 4500 10 4550 -830 {lab=#net22}
N 4520 10 4570 -830 {lab=#net23}
N 4540 10 4590 -830 {lab=#net24}
N 4440 -920 4480 -920 {lab=#net25}
N 4440 -870 4660 -870 {lab=#net25}
N 4440 -920 4440 -870 {lab=#net25}
N 4720 -870 4760 -870 {lab=Vout}
N 4760 -950 4760 -870 {lab=Vout}
N 4390 -610 4680 -610 {lab=VDD}
N 4390 -1210 4390 -610 {lab=VDD}
N 4760 -950 4760 -720 {lab=Vout}
N 4620 -870 4620 -720 {lab=#net25}
N 4440 -990 4480 -990 {lab=#net17}
N 4290 -990 4350 -990 {lab=#net17}
N 4360 -920 4360 -570 {lab=VDD05}
N 4360 -920 4380 -920 {lab=VDD05}
N 4730 -790 4730 -760 {lab=#net25}
N 4620 -790 4730 -790 {lab=#net25}
N 4650 -780 4650 -760 {lab=Vout}
N 4650 -780 4760 -780 {lab=Vout}
N 4680 -750 4680 -720 {lab=Vout}
N 4680 -750 4760 -750 {lab=Vout}
N 4700 -720 4700 -710 {lab=#net25}
N 4620 -710 4700 -710 {lab=#net25}
N 4620 -720 4620 -710 {lab=#net25}
N 4350 -990 4410 -990 {lab=#net17}
N 4650 -720 4650 -710 {lab=#net25}
N 4730 -720 4760 -720 {lab=Vout}
N 4410 -990 4440 -990 {lab=#net17}
N 1130 -1460 1130 -1430 {lab=#net26}
N 1130 -1400 1130 -1370 {lab=GND}
N 1290 -1460 1290 -1430 {lab=#net27}
N 1290 -1400 1290 -1370 {lab=GND}
N 1430 -1460 1430 -1430 {lab=#net28}
N 1430 -1400 1430 -1370 {lab=GND}
N 960 -1520 1130 -1520 {lab=#net19}
N 1130 -1520 1290 -1520 {lab=#net19}
N 1290 -1520 1430 -1520 {lab=#net19}
N 1130 -1370 1290 -1370 {lab=GND}
N 1290 -1370 1430 -1370 {lab=GND}
N 960 -1370 1130 -1370 {lab=GND}
N 960 -1350 960 -820 {lab=GND}
N 1600 -1460 1600 -1350 {lab=GND}
N 1770 -1460 1770 -1430 {lab=#net29}
N 1770 -1400 1770 -1370 {lab=GND}
N 1930 -1460 1930 -1430 {lab=#net30}
N 1930 -1400 1930 -1370 {lab=GND}
N 2070 -1460 2070 -1430 {lab=#net31}
N 2070 -1400 2070 -1370 {lab=GND}
N 1600 -1520 1770 -1520 {lab=#net20}
N 1770 -1520 1930 -1520 {lab=#net20}
N 1930 -1520 2070 -1520 {lab=#net20}
N 1770 -1370 1930 -1370 {lab=GND}
N 1930 -1370 2070 -1370 {lab=GND}
N 1600 -1370 1770 -1370 {lab=GND}
N 1430 -1370 1600 -1370 {lab=GND}
N 1070 -1520 1070 -1120 {lab=#net19}
N 1710 -1520 1710 -990 {lab=#net20}
N 3040 -1520 3040 -1410 {lab=GND}
N 3210 -1520 3210 -1490 {lab=#net32}
N 3210 -1460 3210 -1430 {lab=GND}
N 3370 -1520 3370 -1490 {lab=#net33}
N 3370 -1460 3370 -1430 {lab=GND}
N 3510 -1520 3510 -1490 {lab=#net34}
N 3510 -1460 3510 -1430 {lab=GND}
N 3040 -1580 3210 -1580 {lab=#net17}
N 3210 -1580 3370 -1580 {lab=#net17}
N 3370 -1580 3510 -1580 {lab=#net17}
N 3210 -1430 3370 -1430 {lab=GND}
N 3370 -1430 3510 -1430 {lab=GND}
N 3040 -1430 3210 -1430 {lab=GND}
N 3680 -1520 3680 -1410 {lab=GND}
N 3850 -1520 3850 -1490 {lab=#net35}
N 3850 -1460 3850 -1430 {lab=GND}
N 4010 -1520 4010 -1490 {lab=#net36}
N 4010 -1460 4010 -1430 {lab=GND}
N 4150 -1520 4150 -1490 {lab=#net37}
N 4150 -1460 4150 -1430 {lab=GND}
N 3680 -1580 3850 -1580 {lab=#net18}
N 3850 -1580 4010 -1580 {lab=#net18}
N 4010 -1580 4150 -1580 {lab=#net18}
N 3850 -1430 4010 -1430 {lab=GND}
N 4010 -1430 4150 -1430 {lab=GND}
N 3680 -1430 3850 -1430 {lab=GND}
N 3510 -1430 3680 -1430 {lab=GND}
N 3260 -1580 3260 -1140 {lab=#net17}
N 3040 -1410 3130 -820 {lab=GND}
N 3900 -1580 3900 -990 {lab=#net18}
N 1090 -1400 1090 -1340 {lab=cap0}
N 1090 -1340 1730 -1340 {lab=cap0}
N 1730 -1400 1730 -1340 {lab=cap0}
N 1250 -1400 1250 -1320 {lab=cap1}
N 1250 -1320 1890 -1320 {lab=cap1}
N 1890 -1400 1890 -1320 {lab=cap1}
N 3170 -1460 3170 -1400 {lab=cap0}
N 3170 -1400 3810 -1400 {lab=cap0}
N 3810 -1460 3810 -1400 {lab=cap0}
N 3330 -1460 3330 -1380 {lab=cap1}
N 3330 -1380 3970 -1380 {lab=cap1}
N 3970 -1460 3970 -1380 {lab=cap1}
N 3470 -1460 3470 -1360 {lab=cap2}
N 3470 -1360 4110 -1360 {lab=cap2}
N 4110 -1460 4110 -1360 {lab=cap2}
N 1390 -1400 1390 -1300 {lab=cap2}
N 1390 -1300 2030 -1300 {lab=cap2}
N 2030 -1400 2030 -1300 {lab=cap2}
N 1730 -1340 3170 -1400 {lab=cap0}
N 1890 -1320 3330 -1380 {lab=cap1}
N 2030 -1300 3470 -1360 {lab=cap2}
N 1370 -880 1620 -880 {lab=GND}
N 1620 -880 1650 -1090 {lab=GND}
N 1770 -1210 1770 -1090 {lab=VDD}
N 3960 -1210 3960 -1070 {lab=VDD}
N 3840 -1070 3840 -940 {lab=GND}
N 3540 -920 3840 -940 {lab=GND}
N 3540 -920 3540 -860 {lab=GND}
C {iopin.sym} 890 -1210 3 0 {name=p1 lab=VDD}
C {iopin.sym} -600 140 1 0 {name=p2 lab=GND}
C {ipin.sym} -20 -1030 0 0 {name=p3 lab=Vin}
C {opin.sym} 4760 -950 0 0 {name=p5 lab=Vout}
C {code_shown.sym} 1150 -1050 0 0 {name=s1 only_toplevel=false value=".param m_cap=64"}
C {code_shown.sym} 3310 -1120 0 0 {name=s2 only_toplevel=false value=".param m_cap_1=30"}
C {ipin.sym} 60 -570 0 0 {name=p4 lab=VDD05}
C {ipin.sym} 50 70 0 0 {name=p6 lab=VbiasP}
C {ipin.sym} 50 90 0 0 {name=p7 lab=VbiasN}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_ratio_025.sym} 190 80 0 0 {name=x1}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_ratio_025.sym} 760 80 0 0 {name=x2}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_ratio_04.sym} 1330 80 0 0 {name=x7}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_ratio_04.sym} 1830 80 0 0 {name=x8}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 300 -1000 0 0 {name=x3}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 870 -1000 0 0 {name=x4}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 1440 -1000 0 0 {name=x5}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 1940 -1000 0 0 {name=x6}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 2470 -1000 0 0 {name=x9}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 3040 -1000 0 0 {name=x10}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 3610 -1000 0 0 {name=x11}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 4110 -1000 0 0 {name=x12}
C {symbols/cap_mim_2f0fF.sym} 960 -1490 0 0 {name=C1
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=50}
C {symbols/cap_mim_2f0fF.sym} 1060 -790 0 0 {name=C5
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=48}
C {symbols/cap_mim_2f0fF.sym} 1680 -790 0 0 {name=C6
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=48}
C {symbols/cap_mim_2f0fF.sym} 3260 -790 0 0 {name=C7
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=48}
C {symbols/cap_mim_2f0fF.sym} 3830 -790 0 0 {name=C8
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=48}
C {symbols/cap_mim_2f0fF.sym} 4410 -920 1 0 {name=C9
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=20}
C {symbols/cap_mim_2f0fF.sym} 4690 -870 1 0 {name=C10
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=1}
C {symbols/pfet_03v3.sym} 4730 -740 1 0 {name=M1
L=4u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {symbols/pfet_03v3.sym} 4650 -740 3 1 {name=M2
L=4u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=pfet_03v3
spiceprefix=X
}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA.sym} 4580 -960 0 0 {name=x13}
C {symbols/nfet_03v3.sym} 1110 -1400 0 0 {name=M3
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 1130 -1490 0 0 {name=C11
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=10}
C {symbols/nfet_03v3.sym} 1270 -1400 0 0 {name=M4
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 1290 -1490 0 0 {name=C12
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=20}
C {symbols/nfet_03v3.sym} 1410 -1400 0 0 {name=M5
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 1430 -1490 0 0 {name=C13
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=40}
C {symbols/cap_mim_2f0fF.sym} 1600 -1490 0 0 {name=C2
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=50}
C {symbols/nfet_03v3.sym} 1750 -1400 0 0 {name=M6
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 1770 -1490 0 0 {name=C14
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=10}
C {symbols/nfet_03v3.sym} 1910 -1400 0 0 {name=M7
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 1930 -1490 0 0 {name=C15
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=20}
C {symbols/nfet_03v3.sym} 2050 -1400 0 0 {name=M8
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 2070 -1490 0 0 {name=C16
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=40}
C {symbols/cap_mim_2f0fF.sym} 3040 -1550 0 0 {name=C17
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=50}
C {symbols/nfet_03v3.sym} 3190 -1460 0 0 {name=M9
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 3210 -1550 0 0 {name=C18
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=10}
C {symbols/nfet_03v3.sym} 3350 -1460 0 0 {name=M10
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 3370 -1550 0 0 {name=C19
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=20}
C {symbols/nfet_03v3.sym} 3490 -1460 0 0 {name=M11
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 3510 -1550 0 0 {name=C20
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=40}
C {symbols/cap_mim_2f0fF.sym} 3680 -1550 0 0 {name=C21
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=50}
C {symbols/nfet_03v3.sym} 3830 -1460 0 0 {name=M12
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 3850 -1550 0 0 {name=C22
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=10}
C {symbols/nfet_03v3.sym} 3990 -1460 0 0 {name=M13
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 4010 -1550 0 0 {name=C23
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=20}
C {symbols/nfet_03v3.sym} 4130 -1460 0 0 {name=M14
L=1u
W=0.5u
nf=1
m=1
ad="'int((nf+1)/2) * W/nf * 0.18u'"
pd="'2*int((nf+1)/2) * (W/nf + 0.18u)'"
as="'int((nf+2)/2) * W/nf * 0.18u'"
ps="'2*int((nf+2)/2) * (W/nf + 0.18u)'"
nrd="'0.18u / W'" nrs="'0.18u / W'"
sa=0 sb=0 sd=0
model=nfet_03v3
spiceprefix=X
}
C {symbols/cap_mim_2f0fF.sym} 4150 -1550 0 0 {name=C24
W=10u
L=10u
model=cap_mim_2f0fF
spiceprefix=X
m=40}
C {ipin.sym} 1150 -1340 3 0 {name=p8 lab=cap0}
C {ipin.sym} 1330 -1320 3 0 {name=p9 lab=cap1}
C {ipin.sym} 1460 -1300 3 0 {name=p10 lab=cap2}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_OTA_bias_ratio_5.sym} 4440 90 0 0 {name=x14}
C {symbols/diode_nd2ps_03v3.sym} 1680 -1090 3 0 {name=D1
model=diode_nd2ps_03v3
r_w=1u
r_l=1u
m=5}
C {symbols/diode_pd2nw_03v3.sym} 1740 -1090 3 0 {name=D2
model=diode_pd2nw_03v3
r_w=1u
r_l=1u
m=5}
C {symbols/diode_nd2ps_03v3.sym} 3870 -1070 3 0 {name=D3
model=diode_nd2ps_03v3
r_w=1u
r_l=1u
m=5}
C {symbols/diode_pd2nw_03v3.sym} 3930 -1070 3 0 {name=D4
model=diode_pd2nw_03v3
r_w=1u
r_l=1u
m=5}
