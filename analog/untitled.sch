v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {symbols/diode_nd2ps_03v3.sym} 840 -720 0 0 {name=D1
model=diode_nd2ps_03v3
r_w=1u
r_l=1u
m=1}
