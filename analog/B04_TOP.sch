v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {AURA-Event-Driven-Mixed-Signal-ASIC-for-Acoustic-Pattern-Detection/analog/B04_AFE_top.sym} -20 170 0 0 {name=x1}
C {ipin.sym} -170 210 0 0 {name=p1 lab=Vin}
C {opin.sym} 130 210 0 0 {name=p3 lab=Venvelope}
C {opin.sym} 130 190 0 0 {name=p4 lab=Vbpf}
C {iopin.sym} 130 130 0 0 {name=p5 lab=VDD}
C {iopin.sym} 130 170 0 0 {name=p6 lab=GND}
C {ipin.sym} -170 130 0 0 {name=p8 lab=Cap0}
C {ipin.sym} -170 170 0 0 {name=p2 lab=Vthreshold}
C {opin.sym} 130 150 0 0 {name=p7 lab=Vout}
C {ipin.sym} -170 150 0 0 {name=p9 lab=Cap1}
C {ipin.sym} -170 190 0 0 {name=p10 lab=Cap2}
